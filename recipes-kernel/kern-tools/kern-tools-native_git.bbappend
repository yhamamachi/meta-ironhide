# 
# Base on following:
#     https://git.yoctoproject.org/poky/commit/?id=9b08268bf14ae0118304a33929f239b2c477dbbf
#
SRCREV = "f589e1df23251d8319063da0a61c1016b2a0bf85"
PV = "0.3+git"
